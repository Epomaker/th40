# Keil uVision project ch.uvprojx, settings and files
target ES32F0283_Demo (6180000::V6.18::ARMCLANG)
  device: ES32F0283LT3 Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.15
  cpu: IRAM(0x20000000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: essemi_es32f0283
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=6 v6LangP=5 wLevel=3
  c define: HAL_USE_USB=TRUE TEST_CFG_SIZE_REPORT=0 __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base  KEYBOARD_ KEYBOARD_ KEYBOARD_ KEYBOARD_essemi KEYBOARD_essemi_es32f0283 KEYMAP_C=\"../../../../../../keyboards/essemi/es32f0283/keymaps/via/keymap.c\" PRINTF_SUPPORT_DECIMAL_SPECIFIERS=0 PRINTF_SUPPORT_EXPONENTIAL_SPECIFIERS=0 PRINTF_SUPPORT_LONG_LONG=0 PRINTF_SUPPORT_WRITEBACK_SPECIFIER=0 SUPPORT_MSVC_STYLE_INTEGER_SPECIFIERS=0 PRINTF_ALIAS_STANDARD_FUNCTION_NAMES=1 EEPROM_ENABLE EEPROM_VENDOR EEPROM_DRIVER EEPROM_TRANSIENT BOOTMAGIC_LITE DYNAMIC_KEYMAP_ENABLE GRAVE_ESC_ENABLE MAGIC_ENABLE SEND_STRING_ENABLE SPACE_CADET_ENABLE TRI_LAYER_ENABLE RGB_MATRIX_ENABLE VIA_ENABLE RAW_ENABLE NO_PRINT NO_DEBUG SHARED_EP_ENABLE BOOTLOADER_CUSTOM CORTEX_USE_FPU=FALSE PROTOCOL_CHIBIOS MCU_ES32 PLATFORM_SUPPORTS_SYNCHRONIZATION PORT_IGNORE_GCC_VERSION_CHECK=1 FIXED_CONTROL_ENDPOINT_SIZE=64 FIXED_NUM_CONFIGURATIONS=1 QMK_MCU="ES32F0283" QMK_MCU_ES32F0283 QMK_MCU_ARCH="cortex-m0" QMK_MCU_ARCH_CORTEX_M0 QMK_MCU_PORT_NAME="ES32" QMK_MCU_PORT_NAME_ES32 QMK_MCU_FAMILY="ES32" QMK_MCU_FAMILY_ES32 QMK_MCU_SERIES="ES32F0283" QMK_MCU_SERIES_ES32F0283 QMK_BOARD="ES32F0283" QMK_BOARD_ES32F0283 QMK_KEYBOARD=\"essemi/es32f0283\" QMK_KEYBOARD_H=\"../../../../../../.build/obj_essemi_es32f0283_via/src/default_keyboard.h\" QMK_KEYMAP=\"via\" QMK_KEYMAP_H=\"via.h\" QMK_KEYMAP_CONFIG_H=\"../../../../../../keyboards/essemi/es32f0283/keymaps/via/config.h\" KEYBOARD_ KEYBOARD_ KEYBOARD_ KEYBOARD_essemi KEYBOARD_essemi_es32f0283 KEYMAP_C=\"../../../../../../keyboards/essemi/es32f0283/keymaps/via/keymap.c\" PRINTF_SUPPORT_DECIMAL_SPECIFIERS=0 PRINTF_SUPPORT_EXPONENTIAL_SPECIFIERS=0 PRINTF_SUPPORT_LONG_LONG=0 PRINTF_SUPPORT_WRITEBACK_SPECIFIER=0 SUPPORT_MSVC_STYLE_INTEGER_SPECIFIERS=0 PRINTF_ALIAS_STANDARD_FUNCTION_NAMES=1 EEPROM_ENABLE EEPROM_VENDOR EEPROM_DRIVER EEPROM_TRANSIENT GRAVE_ESC_ENABLE MAGIC_ENABLE SEND_STRING_ENABLE SPACE_CADET_ENABLE NO_PRINT NO_DEBUG SHARED_EP_ENABLE BOOTLOADER_CUSTOM CORTEX_USE_FPU=FALSE PROTOCOL_CHIBIOS MCU_ES32 PLATFORM_SUPPORTS_SYNCHRONIZATION PORT_IGNORE_GCC_VERSION_CHECK=1 FIXED_CONTROL_ENDPOINT_SIZE=64 FIXED_NUM_CONFIGURATIONS=1 QMK_MCU="ES32F0283" QMK_MCU_ES32F0283 QMK_MCU_ARCH="cortex-m0" QMK_MCU_ARCH_CORTEX_M0 QMK_MCU_PORT_NAME="ES32" QMK_MCU_PORT_NAME_ES32 QMK_MCU_FAMILY="ES32" QMK_MCU_FAMILY_ES32 QMK_MCU_SERIES="ES32F0283" QMK_MCU_SERIES_ES32F0283 QMK_BOARD="ES32F0283" QMK_BOARD_ES32F0283 ES_INCLUDE_INFO_CONFIG_FILE
  c include: ..\;..\..\..\..\..\..\.build\obj_essemi_es32f0283_via\src;..\..\..\..\..\..\keyboards\essemi\es32f0283\via;..\..\..\..\..\..\keyboards\essemi\es32f0283;..\..\..\..\os\license;..\..\..\..\..\chibios-contrib\os\common\startup\ARMCMx\devices\ES32F0283;..\..\..\..\os\common\ext\ARM\CMSIS\Core\Include;..\..\..\..\os\common\portability\Keil;..\..\..\..\os\common\ports\ARM-common;..\..\..\..\os\common\ports\ARMv6-M;..\..\..\..\os\rt\include;..\..\..\..\os\oslib\include;..\..\..\..\os\hal\osal\rt-nil;..\..\..\..\os\hal\include;..\..\..\..\..\chibios-contrib\os\hal\boards\ES32F0283;..\..\..\..\os\hal\ports\common\ARMCMx;..\..\..\..\..\chibios-contrib\os\hal\ports\ES32\ES32F0283;..\..\..\..\os\test\include;..\..\..\..\test\rt\source\test;..\..\..\..\test\oslib\source\test;..\..\..\..\..\chibios-contrib\os\common\ext\CMSIS\ES32\ES32F0283;..\..\..\..\..\chibios-contrib\os\common\ext\CMSIS\ES32\ES32F0283\ES32F0283;..\..\..\..\..\chibios-contrib\os\common\ext\CMSIS\ES32\ES32F0283\ald;..\..\..\..\..\chibios-contrib\os\common\ext\CMSIS\ES32\ES32F0283\md;..\..\..\..\..\chibios-contrib\os\hal\ports\ES32\LLD\ADCv1;..\..\..\..\..\chibios-contrib\os\hal\ports\ES32\LLD\USBv1;..\..\..\..\..\chibios-contrib\os\hal\ports\ES32\LLD\GPIOv1;..\..\..\..\..\chibios-contrib\os\hal\ports\ES32\LLD\I2Cv1;..\..\..\..\..\chibios-contrib\os\hal\ports\ES32\LLD\SPIv1;..\..\..\..\..\chibios-contrib\os\hal\ports\ES32\LLD\TIMv1;..\..\..\..\..\chibios-contrib\os\hal\ports\ES32\LLD\UARTv1;..\..\..\..\..\..\platforms\chibios\boards\common\configs;..\..\..\..\..\..\quantum;..\..\..\..\..\..\tmk_core\protocol;..\..\..\..\..\..\quantum\logging;..\..\..\..\..\..\platforms;..\..\..\..\..\..\platforms\chibios;..\..\..\..\..\..\tmk_core\protocol\chibios\lufa_utils\LUFA\Drivers\USB;..\..\..\..\..\..\drivers\eeprom;..\..\..\..\..\..\quantum\keymap_extras;..\..\..\..\..\..\quantum\sequencer;..\..\..\..\..\..\quantum\bootmagic;..\..\..\..\..\..\quantum\process_keycode;..\..\..\..\..\..\quantum\send_string;..\..\..\..\..\lufa\LUFA\Drivers\USB\Class\Common;..\..\..\..\..\lufa\LUFA\Drivers\USB\Core;..\..\..\..\..\..\drivers;..\..\..\..\..\..\quantum;..\..\..\..\..\..\quantum\rgb_matrix
  asm include: ..\..\..\..\os\license;..\..\..\..\..\chibios-contrib\os\common\startup\ARMCMx\devices\ES32F0283;..\..\..\..\..\chibios-contrib\os\hal\boards\ES32F0283;..\..\..\..\..\..\platforms\chibios\boards\common\configs;..\..\..\..\os\common\ports\ARMv6-M
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\essemi_es32f0283.sct
  group license
    ../../../../os/license/: chcustomer.h chlicense.h chversion.h
  group startup
    ../../../../../chibios-contrib/os/common/startup/ARMCMx/devices/ES32F0283/: cmparams.h
  group cmsis
    ../../../../os/common/ext/ARM/CMSIS/Core/Include/: cmsis_gcc.h core_cm0.h
  group kernel port
    ../../../../os/common/ports/ARMv6-M/: chcore.c chcore.h
  group kernel
    ../../../../os/rt/include/: chalign.h ch.h chcond.h chdebug.h chdynamic.h chevents.h chmsg.h chmtx.h chregistry.h chschd.h chsem.h chstats.h chsys.h chthreads.h chtm.h chvt.h chchecks.h chtrace.h chrestrictions.h chtime.h
    ../../../../os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chmsg.c chmtx.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chvt.c chrfcu.c chinstances.c chtrace.c
  group oslib
    ../../../../os/oslib/include/: chbsem.h chdelegates.h chfactory.h chjobs.h chlib.h chmboxes.h chmemcore.h chmemheaps.h chmempools.h chobjcaches.h chobjfifos.h chpipes.h
    ../../../../os/oslib/src/: chdelegates.c chfactory.c chmboxes.c chmemcore.c chmemheaps.c chmempools.c chobjcaches.c chpipes.c
  group osal
    ../../../../os/hal/osal/rt-nil/: osal.c osal.h
  group hal
    ../../../../os/hal/include/: hal.h hal_adc.h hal_buffers.h hal_can.h hal_channels.h hal_dac.h hal_files.h hal_gpt.h hal_i2c.h hal_i2s.h hal_icu.h hal_ioblock.h hal_mac.h hal_mii.h hal_mmc_spi.h hal_mmcsd.h hal_pal.h hal_pwm.h hal_queues.h hal_rtc.h hal_sdc.h hal_serial.h hal_serial_usb.h hal_spi.h hal_st.h hal_streams.h hal_uart.h hal_usb.h hal_usb_cdc.h hal_wdg.h hal_crypto.h hal_efl.h hal_flash.h hal_objects.h hal_persistent.h hal_sio.h hal_trng.h hal_wspi.h
    ../../../../os/hal/src/: hal.c hal_adc.c hal_buffers.c hal_can.c hal_dac.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_spi.c hal_st.c hal_uart.c hal_usb.c hal_wdg.c hal_crypto.c hal_efl.c hal_flash.c hal_sio.c hal_trng.c hal_wspi.c
  group hal_port
    ../../../../../chibios-contrib/os/hal/ports/ES32/ES32F0283/: es32_registry.h hal_lld.c hal_lld.h
    ../../../../../chibios-contrib/os/hal/ports/ES32/LLD/ADCv1/: hal_adc_lld.c hal_adc_lld.h
    ../../../../../chibios-contrib/os/hal/ports/ES32/LLD/GPIOv1/: hal_pal_lld.c hal_pal_lld.h
    ../../../../../chibios-contrib/os/hal/ports/ES32/LLD/I2Cv1/: hal_i2c_lld.c hal_i2c_lld.h
    ../../../../../chibios-contrib/os/hal/ports/ES32/LLD/SPIv1/: hal_spi_lld.c hal_spi_lld.h
    ../../../../../chibios-contrib/os/hal/ports/ES32/LLD/TIMv1/: hal_gpt_lld.c hal_gpt_lld.h hal_pwm_lld.c hal_pwm_lld.h hal_st_lld.c hal_st_lld.h
    ../../../../../chibios-contrib/os/hal/ports/ES32/LLD/UARTv1/: hal_serial_lld.c hal_serial_lld.h hal_uart_lld.c hal_uart_lld.h
    ../../../../../chibios-contrib/os/hal/ports/ES32/LLD/USBv1/: hal_usb_lld.c hal_usb_lld.h
    ../../../../../chibios-contrib/os/hal/ports/ES32/LLD/WDTv1/: hal_wdg_lld.c hal_wdg_lld.h
  group board
    ../../../../../chibios-contrib/os/hal/boards/ES32F0283/: board.c board.h
  group demo
    ../../../../../../keyboards/essemi/es32f0283/: chconf.h config.h halconf.h mcuconf.h
  group chip_lib
    ../../../../../chibios-contrib/os/common/ext/CMSIS/ES32/ES32F0283/ald/: ald_usb.c ald_usb.h utils.c utils.h
    ../../../../../chibios-contrib/os/common/ext/CMSIS/ES32/ES32F0283/md/: md_adc.c md_adc.h md_aes.h md_calc.h md_cmp.h md_crc.c md_crc.h md_csu.c md_csu.h md_dma.c md_dma.h md_exti.h md_fc.c md_fc.h md_gpio.c md_gpio.h md_i2c.c md_i2c.h md_iwdt.h md_kbcu.h md_rcu.c md_rcu.h md_rtc.c md_rtc.h md_spi.c md_spi.h md_syscfg.h md_tick.c md_tick.h md_timer.h md_uart.c md_uart.h md_usb.h md_utils.c md_utils.h md_wwdt.c md_wwdt.h type.h
    ../../../../../chibios-contrib/os/common/ext/CMSIS/ES32/ES32F0283/: system_es32f0283.c
  group quantum
    ../../../../../../quantum/: quantum.c keymap_introspection.c action_layer.c action.c led.c eeconfig.c action_util.c action_tapping.c keymap_common.c keyboard.c matrix.c matrix_common.c main.c bitwise.c keycode_config.c via.c tri_layer.c dynamic_keymap.c color.c command.c mousekey.c
    ../../../../../../quantum/logging/: print.c sendchar.c debug.c
    ../../../../../../quantum/bootmagic/: magic.c bootmagic_lite.c
    ../../../../../../quantum/debounce/: sym_defer_g.c
    ../../../../../../quantum/process_keycode/: process_space_cadet.c process_magic.c process_grave_esc.c process_tri_layer.c process_backlight.c
    ../../../../../../quantum/send_string/: send_string.c
    ../../../../../../quantum/rgb_matrix/: rgb_matrix.c rgb_matrix_drivers.c
    ../../../../../../quantum/backlight/: backlight.c backlight_driver_common.c
    ../../../../../../platforms/chibios/drivers/: backlight_pwm.c ws2812_bitbang.c
    ../../../../../lib8tion/: lib8tion.c
  group protocol
    ../../../../../../tmk_core/protocol/: host.c report.c usb_device_state.c usb_util.c usb_descriptor.c
    ../../../../../../tmk_core/protocol/chibios/: chibios.c usb_driver.c usb_main.c
  group platforms
    ../../../../../../platforms/: suspend.c
    ../../../../../../platforms/chibios/: platform.c timer.c
    ../../../../../../platforms/chibios/bootloaders/: custom.c
  group s
    ../../../../os/common/startup/ARMCMx/compilers/RVCT/: cstartup_1.s vectors_1.s
    ../../../../os/common/ports/ARMv6-M/compilers/RVCT/: chcoreasm_1.s
  group drivers
    ../../../../../../drivers/eeprom/: eeprom_driver.c eeprom_transient.c
  group user
    ../: es_app.c
    ../../../../../../keyboards/essemi/es32f0283/: es32f0283.c
